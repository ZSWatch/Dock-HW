# Repository ZSWatch/Dock-HW

File README.md:

> [!IMPORTANT]  
> This is a prototype right now, not fully tested. Do not order.
> Please use https://github.com/ZSWatch/Watch-DevKit-HW until this PCB is finalized.

View this project on [CADLAB.io](https://cadlab.io/project/29657). 

# ZSWatch-Dock

## 📑 Table of Contents

- [ZSWatch-Dock](#zswatch-dock)
  - [📑 Table of Contents](#-table-of-contents)
  - [📖 About](#-about)
  - [📂 Directory Breakdown](#-directory-breakdown)
  - [Purchasing](#purchasing)
  - [👨‍💻 Maintainer](#-maintainer)

## 📖 About

The **ZSWatch-Dock** project provides the hardware design and production files for a docking station tailored to the ZSWatch ecosystem.  
It is built with **KiCad** and integrates a full **CI/CD pipeline** using **KiBot**, ensuring reproducible outputs for documentation, manufacturing, and releases.

Key features:

- 🛠️ Open-source hardware design
- 📦 Automated generation of Gerber, BoM, and documentation via KiBot
- 🔄 Workflow stages (DRAFT → PRELIMINARY → CHECKED → RELEASED) for structured releases
- 📝 Clear documentation and changelog to track progress
- 🌍 Designed with collaboration and transparency in mind

Please check the [wiki](https://github.com/ZSWatch/ZSWatch/wiki) for more information about the project.

## 📂 Directory Breakdown

- **`.github`**: GitHub related files
- **`.gitignore`**: Ignored files list
- **`dock`**: KiCad project for the dock
- **`production`**: Manufacturing outputs (Gerbers, documentation, etc.)
- **`CHANGELOG.md`**: Version history
- **`LICENSE`**: Project license (GPL-3.0)
- **`README.md`**: Project overview

## Purchasing

TBD

## 👨‍💻 Maintainer

- [Daniel Kampert](mailto:danielkameprt@kampis-elektroecke.de)
- [Jakob Krantz](mailto:mail@jakobkrantz.se)

## KiCad design dock/ZSWatch-Dock.kicad_pcb

File dock/README.md:

<h1 align="center">Template</h1>

<p align="center" width="100%">
  
</p>

***

<p align="center">
  
&nbsp; &nbsp; &nbsp; &nbsp;
  
</p>

***

## SPECIFICATIONS

| Parameter | Value |
| --- | --- |
| Dimensions | 32.0 × 24.0 mm |

***

## DIRECTORY STRUCTURE

    .
    ├─ Computations       # Misc calculations
    ├─ HTML               # HTML files for generated webpage
    ├─ Images             # Pictures and renders
    │
    ├─ kibot_resources    # External resources for KiBot
    │  ├─ colors          # Color theme for KiCad
    │  ├─ fonts           # Fonts used in the project
    │  ├─ scripts         # External scripts used with KiBot
    │  └─ templates       # Templates for KiBot generated reports
    │
    ├─ kibot_yaml         # KiBot YAML config files
    ├─ KiRI               # KiRI (PCB diff viewer) files
    │
    ├─ lib                # KiCad footprint and symbol libraries
    │  ├─ 3d_models       # Component 3D models
    │  ├─ lib_fp          # Footprint libraries
    │  └─ lib_sym         # Symbol libraries
    │
    ├─ logos              # Logos
    │
    ├─ Manufacturing      # Assembly and fabrication documents
    │  ├─ Assembly        # Assembly documents (BoM, pos, notes)
    │  │
    │  └─ Fabrication     # Fabrication documents (ZIP, notes)
    │     ├─ Drill Tables # CSV drill tables
    │     └─ Gerbers      # Gerbers
    │
    ├─ Report             # Reports for ERC/DRC
    ├─ Schematic          # PDF of schematic
    ├─ templates          # Title block templates
    ├─ Testing
    │  └─ Testpoints      # Testpoints tables
    │
    └─ Variants           # Outputs for assembly variants

Notes on the sheet:
Variant: ${VARIANT}
RELEASED - A board with this schematic has been sent to production.
${SHEET_NAME_24}
Index
Page
PRELIMINARY - Close to final schematic.
${SHEET_NAME_22}
DRAFT - Very early stage of schematic, ignore details.
${SHEET_NAME_12}
${SHEET_NAME_8}
${SHEET_NAME_2}
${SHEET_NAME_5}
${SHEET_NAME_20}
${SHEET_NAME_23}
${RELEASE_DATE_NUM}
${SHEET_NAME_35}
Not fitted components are marked as
${SHEET_NAME_11}
${SHEET_NAME_6}
${SHEET_NAME_37}
${SHEET_NAME_26}
${SHEET_NAME_36}
Rev ${REVISION}
${SHEET_NAME_15}
CHECKED - There shouldn't be any mistakes. Contact the engineer if you find any.
BOTTOM VIEW
${SHEET_NAME_14}
${SHEET_NAME_21}
${SHEET_NAME_17}
${SHEET_NAME_18}
Date: ${RELEASE_DATE}
${SHEET_NAME_7}
${SHEET_NAME_31}
${BOARD_NAME}
NOTES
${SHEET_NAME_40}
${SHEET_NAME_39}
${SHEET_NAME_32}
${SHEET_NAME_1}
${SHEET_NAME_9}

Notes on the sheet:
${RELEASE_BODY_...}
[${#}] ${TITLE}
${RELEASE_BODY_2.2.0}
${RELEASE_TITLE_...}
${RELEASE_TITLE_2.2.0}

Notes on the sheet:
Spec 4
+5 V
[${#}] ${TITLE}
Input voltage:
Target specifications:
Spec 3
Spec 2

Notes on the sheet:
Page 4

Parts:
C401, C403, C404, C405, C406, C407, C409, C414, C415, C416, C417, C418, C419: 100n; C_0603_1608Metric; mouser# 80-C0603C104M4R7411
C402, C411: 2u2; C_0603_1608Metric; mouser# 581-0603YD225KAT4A
C408: 470p; C_0603_1608Metric; mouser# 581-06031C471K4Z4A
C410: 1u; C_0603_1608Metric; mouser# 810-C1608X7R1H105K08
C412, C413: 18p; C_0603_1608Metric; mouser# 581-06031A180KAT2A
D401, D402: ESD5Zxx; D_SOD-523; mouser# 863-ESD5Z5.0T5G
D403: USB; LED_0603_1608Metric; mouser# 720-LGL29KG2J124Z
D404: Charge; LED_0603_1608Metric; mouser# 710-150060YS75020
IC401: TLV70218_SOT23-5; SOT-23-5; mouser# 595-TLV70218DBVRG4
IC402, IC406, IC408: USBLC6-2P6; SOT-666; mouser# 511-USBLC6-2P6
IC403: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm; mouser# 895-FT230XQ-R
IC404: MIC5219-3.3YM5; SOT-23-5; mouser# 998-MIC5219-3.3YM5TR
IC405: TXB0304RUT; Texas_R-PUQFN-N12; mouser# 595-TXB0304RUTR
IC407: USB2512BT; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm; mouser# 579-USB2512BT/M2
IC409: MIC2026-1xM; SOIC-8_3.9x4.9mm_P1.27mm; mouser# 998-MIC2026-1YM
J401: Jumper; mouser# 710-60900213421
J402: Voltage; PinHeader_1x03_P2.54mm_Vertical; mouser# 649-10129378-936001BLF
Q401: BSH205G2AR; SOT-23; mouser# 771-BSH205G2AR
R401, R404, R408, R412, R413, R414, R419, R420: 100k; R_0603_1608Metric; mouser# 603-RC0603FR-07100KL
R402, R403: 22R; R_0603_1608Metric; mouser# 652-CR0603-JW-220ELF
R405, R418: 0R; R_0805_2012Metric; mouser# 652-CR0805-J/-000ELF
R406: 0R; R_0805_2012Metric; mouser# 652-CR0805-J/-000ELF; not fitted
R407: 3k3; R_0603_1608Metric; mouser# 71-CRCW06033K300FKEA
R409, R410: 5k1; R_0603_1608Metric; mouser# 71-CRCW06035K10FKEA
R411: 1M; R_0603_1608Metric; not fitted
R417: 12k / 1%; R_0603_1608Metric; mouser# 652-CR0603-FX-1202ELF
R421: 620R; R_0603_1608Metric; mouser# 652-CR0603-JW-621ELF
S401: Reset; WS-TASV-6x6; mouser# 710-430182050816
SB401: Resetn; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; not fitted
SB402: SWDCLK; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; not fitted
SB403: SWDIO; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; not fitted
SW401: Charge; SW_SPDT_PCM12; mouser# 611-PCM12SMTR
X401: Debug; SHF-105-01-L-D-SM-TR; mouser# 710-62101021021
X402: UART; PinHeader_1x03_P2.54mm_Vertical
X403: Host; USB_C_Receptacle_Amphenol_12401610E4-2A; mouser# 523-12401610E4#2A
X404: Device; PLUG-USBC-241SMT-4BC2SS; digikey# 1939-PLUG-USBC-241SMT-4BC2SSCT-ND
X405: Current; PinHeader_1x02_P2.54mm_Horizontal; not fitted
Y401: 24 MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm; mouser# 815-ABM8G-24-B4Y-T

Connections:
+1V8: C402.1, C407.1, C409.1, IC401.5 (OUT), IC403.1 (VCCIO), IC405.1 (VCCA), J402.3, R405.1
+3V3: C404.1, C405.1, C410.1, C411.1, C415.1, C416.1, IC403.8 (3V3OUT), IC403.10 (VCC), IC404.5 (OUT), IC407.5 (VDDA), IC407.10 (VDDA), IC407.15 (VDD), IC407.23 (VDD), IC407.29 (VDDA), IC407.36 (VDDA), J402.1, R401.1, R404.1, R412.1, R413.1, R414.1
/Project Architecture/Main/D+: IC406.4 (I/O2), X403.A6 (D+), X403.B6 (D+)
/Project Architecture/Main/D-: IC406.6 (I/O1), X403.A7 (D-), X403.B7 (D-)
/Project Architecture/Main/D_{2}+: IC408.4 (I/O2), X404.A6 (D+)
/Project Architecture/Main/D_{2}-: IC408.6 (I/O1), X404.A7 (D-)
EN_{OC1}: IC407.12 (PRTPWR1/BC_EN1), IC409.1 (ENA), R412.2
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.1, C413.1, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, D402.2 (A), D403.1 (K), IC401.2 (GND), IC402.2 (GND), IC403.3 (GND), IC403.13 (GND), IC403.17 (GND), IC404.2 (GND), IC405.6 (GND), IC406.2 (GND), IC407.16 (PRTPWR2/BC_EN2), IC407.24 (SCL/SMBCLK/CFG_SEL0), IC407.25 (HS_IND/CFG_SEL1), IC407.37 (GND), IC408.2 (GND), IC409.6 (GND), R406.2, R408.2, R409.2, R410.1, R417.2, R419.2, S401.2, SW401.2 (B), X401.3 (GND), X401.5 (GND), X402.2, X403.A1 (GND), X403.A12 (GND), X403.B1 (GND), X403.B12 (GND), X403.S1 (SHIELD), X404.A1 (GND), X404.A12 (GND), X404.B1 (GND), X404.B12 (GND), X404.S1 (SHIELD), Y401.2, Y401.4
unnamed: C406.1, D401.1 (K), IC402.5 (VBUS), IC405.11 (VCCB), J402.2, X401.1 (VTref)
unnamed: D403.2 (A), R407.1
unnamed: D404.2 (A), R421.1
unnamed: D404.1 (K), Q401.1 (G), R420.1, SW401.3 (C)
unnamed: IC402.6 (I/O1), R402.1
unnamed: IC402.4 (I/O2), R403.1
unnamed: C403.1, IC403.9 (~RESET), R404.2
unnamed: C408.1, IC404.4 (BP)
unnamed: IC402.1 (I/O1), IC405.8 (B3), SB402.1 (A)
unnamed: IC402.3 (I/O2), IC405.7 (B4), SB403.1 (A)
unnamed: IC405.12 (OE), R405.2, R406.1
unnamed: C418.1, IC407.14 (CRFILT)
unnamed: IC407.13 (OCS_{N1}), IC409.2 (FLGA)
unnamed: C417.1, IC407.34 (PLLFILT)
unnamed: IC407.35 (RBIAS), R417.1
unnamed: IC407.22 (SDA/SMBDATA/NON_REM1), R413.2
unnamed: IC407.28 (SUSP_IND/LOCAL_PWR/NON_REM0), R407.2, R408.1
unnamed: C412.2, IC407.33 (XTAL_{IN}), R411.1, Y401.1
unnamed: C413.2, IC407.32 (XTAL_{OUT}), R411.2, Y401.3
unnamed: C414.1, IC407.26 (~RESET), R414.2
unnamed: IC409.4 (ENB), R419.1
unnamed: Q401.3 (D), R418.1, X405.2
unnamed: R402.2, X401.4 (SWCLK/TCK)
unnamed: R403.2, X401.2 (SWDIO/TMS)
unnamed: R410.2, X403.A5 (CC1)
unnamed: R409.1, X403.B5 (CC2)
unnamed: R418.2, X404.A4 (VBUS), X404.A9 (VBUS), X404.B4 (VBUS), X404.B9 (VBUS), X405.1
RESETn: C401.1, D401.2 (A), D402.1 (K), IC405.9 (B2), IC405.10 (B1), R401.2, S401.1, SB401.1 (A), X401.10 (~RESET)
RESETn_{LV}: IC405.2 (A1), IC405.3 (A2), SB401.2 (B), X404.A8 (SBU1)
RxD_{LV}: IC403.2 (RXD), X402.1, X404.A2 (TX1+)
SWDCLK_{LV}: IC405.4 (A3), SB402.2 (B), X404.A11 (RX2+)
SWDIO_{LV}: IC405.5 (A4), SB403.2 (B), X404.A10 (RX2-)
TxD_{LV}: IC403.15 (TXD), X402.3, X404.A3 (TX1-)
USB-1-D+: IC403.6 (USBDP), IC407.4 (USBDP_{N2})
USB-1-D-: IC403.7 (USBDM), IC407.3 (USBDM_{N2})
USB-2-D+: IC407.2 (USBDP_{N1}), IC408.3 (I/O2)
USB-2-D-: IC407.1 (USBDM_{N1}), IC408.1 (I/O1)
USB-D+: IC406.3 (I/O2), IC407.31 (USBDP_{UP})
USB-D-: IC406.1 (I/O1), IC407.30 (USBDM_{UP})
V_{BUS}: C419.1, IC401.1 (IN), IC401.3 (EN), IC404.1 (IN), IC404.3 (EN), IC406.5 (VBUS), IC407.27 (VBUS), IC409.7 (IN), X403.A4 (VBUS), X403.A9 (VBUS), X403.B4 (VBUS), X403.B9 (VBUS)
V_{Watch}: IC408.5 (VBUS), IC409.8 (OUTA), Q401.2 (S), R420.2, R421.2

Notes on the sheet:
ZSWatch
90 Ohm ± 15%
FT230X
USB (To Host/Computer)
1V8 Regulator
SWD
Active-high for MIC20x6-1
USB (To Client/ZSWatch)
3V3 Regulator
Active-low output with Pull-Up on USB hub
USB251xB contains an internal 1M resistor
Swap these resistors when using the TXBN variant!
Reset
Low ESR capacitors
USB <-> UART
1V8 domain
Hub configuration: - All ports are non-removable (REM0 = low and REM1 = high) - LED is active low (REM0 = low and REM1 = high) - Strap options enabled (CFG_SEL0 and CFG_SEL1 = low) - Self-powered operation enabled (CFG_SEL0 and CFG_SEL1 = low) - Individual power switching enabled (CFG_SEL0 and CFG_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

Board: 4 copper layers, 80.0 x 48.0 mm, 68 parts (3 on the bottom side), 49 nets.

Other parts of the board:
kibuzzard-6832BFA7: G***; kibuzzard-6832BFA7
kibuzzard-6832BFEF: G***; kibuzzard-6832BFEF
kibuzzard-68303879: G***; kibuzzard-68303879
kibuzzard-68304463: G***; kibuzzard-68304463

## Commit log

2025-05-09 ci: Fix ci/cd issue.
2025-05-09 Add image from CI/CD action
2025-07-11 Dock: Revision 0
2025-07-11 Dock: Revision 1
    - Fix wrong title for USB Host and Device
    - Fix missing VBus for +3V3 and +1V8 rail
    - Set revision to 1
2025-07-23 Issue #44
2025-07-24 Issue #45
2025-07-24 Issue #46
2025-07-24 Issue #47, Issue #48
2025-07-26 Issue #49
2025-07-26 Issue #54 and Issue #50
2025-07-26 Issue #52, with DRC issues from previous commit
2025-08-01 Issue #42
2025-08-01 Issue #58
2025-08-01 Issue #51, Clean up Copy+Paste errors in Schematics
2025-08-03 Issue #60
2025-08-24 Issue #59
2025-08-24 Issue #61
2025-08-31 Working on CI/CD pipeline
2025-09-07 Bug: Issue #44
2025-09-07 Bug: Issue #45
2025-09-07 Bug: Issue #46
2025-09-07 Bug: Issue #47, Issue #48
2025-09-07 Bug: Issue #49
2025-09-07 Feature: Issue #54 and Issue #50
2025-09-07 Feature: Issue #52
2025-09-07 doc: Issue #42
2025-09-07 Feature: Issue #58
2025-09-07 Bug: Issue #51
2025-09-07 Feature: Issue #60
2025-09-07 Feature: Issue #59
2025-09-07 Feature: Issue #61
2025-09-07 doc: CI/CD fixes
2025-09-07 Prepare release
    - Set variant to CHECKED
    - Remove unused files
    - Fix ERC errors
    - Fix DRC errors
    - Remove Power Sequencing page
2025-09-18 Release 2.2.0
    - Set variant to CHECKED
    - Remove unused files
    - Fix ERC errors
    - Fix DRC errors
    - Remove Power Sequencing page
    - Add block diagram
2025-09-18 Update CHANGELOG
2025-09-18 Update outputs (release)
2025-10-08 Backlink to CADLAB.io has been added.
2025-11-14 Initialize development branch for version 2.2.1
2025-11-14 Bug: Issue #48
    - Flip Rx and Tx lines for UART and SWD
    - Update .gitignore
    Closes #48
2025-11-18 Task: Issue #70
    - Add BOM fixes from watch-dk project
    Closes #70
2025-11-18 Task: Issue #68
    - Add commit template
    Closes #68
2025-11-18 Bug: Issue #67
    - Remove logs from pipeline results
    Closes #67
2025-11-18 Task: Issue #69
    - Change ZSWatch USB to a single sided and more stable one
    Closes #69
2025-11-20 Task: Issue #72
    - Move Voltage REF connector a little
    Closes #72
2025-11-22 Task: Fix DNP layers
    - Bring back Eco1 and Eco2 layers
    - Add additional layers for DNP components
2025-12-11 Change template and logo path
2026-02-21 CI/CD fixes
2026-02-21 Bug: Remove box around the version number
    - Causes issues when building prod files for prereleases
    - Fix wrong tabs in CHANGELOG.md
    Closes #73, #74
2026-02-23 Bug: Issue #75
    - Fix logo and badge in CI/CD
    - Add wrl to step conversion for 3D models to CI/CD
    Closes: #75
2026-02-23 Push outputs from CI/CD (2026-02-23 09:21:53)
2026-04-10 Fix wrong datasheet link for USB connector
2026-04-17 Update README with prototype warning and link
    Added important notice about the prototype status and alternative link.
2026-06-01 Task: Issue #77
    - Update CHANGELOG format to the latest version and add changelog check CI/CD
    Closes: #77
2026-06-01 Bug: Issue #73, #74
    - Causes issues when building prod files for prereleases
    - Fix wrong tabs in CHANGELOG.md
    Closes #73, #74
2026-06-01 Prepare release 2.2.1
